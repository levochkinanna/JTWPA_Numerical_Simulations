I1 0 N001  I
R1 0 N001 R
XSN1 N001 N002 snail
XSN2 N002 N003 snail_reversed
XSN3 N003 N004 snail
XSN4 N004 N005 snail_reversed
XSN5 N005 N006 snail
XSN6 N006 N007 snail_reversed
XSN7 N007 N008 snail
XSN8 N008 N009 snail_reversed
XSN9 N009 N010 snail
XSN10 N010 N011 snail_reversed
XSN11 N011 N012 snail
XSN12 N012 N013 snail_reversed
XSN13 N013 N014 snail
XSN14 N014 N015 snail_reversed
XSN15 N015 N016 snail
XSN16 N016 N017 snail_reversed
XSN17 N017 N018 snail
XSN18 N018 N019 snail_reversed
XSN19 N019 N020 snail
XSN20 N020 N021 snail_reversed
XSN21 N021 N022 snail
XSN22 N022 N023 snail_reversed
XSN23 N023 N024 snail
XSN24 N024 N025 snail_reversed
XSN25 N025 N026 snail
XSN26 N026 N027 snail_reversed
XSN27 N027 N028 snail
XSN28 N028 N029 snail_reversed
XSN29 N029 N030 snail
XSN30 N030 N031 snail_reversed
XSN31 N031 N032 snail
XSN32 N032 N033 snail_reversed
XSN33 N033 N034 snail
XSN34 N034 N035 snail_reversed
XSN35 N035 N036 snail
XSN36 N036 N037 snail_reversed
XSN37 N037 N038 snail
XSN38 N038 N039 snail_reversed
XSN39 N039 N040 snail
XSN40 N040 N041 snail_reversed
XSN41 N041 N042 snail
XSN42 N042 N043 snail_reversed
XSN43 N043 N044 snail
XSN44 N044 N045 snail_reversed
XSN45 N045 N046 snail
XSN46 N046 N047 snail_reversed
XSN47 N047 N048 snail
XSN48 N048 N049 snail_reversed
XSN49 N049 N050 snail
XSN50 N050 N051 snail_reversed
XSN51 N051 N052 snail
XSN52 N052 N053 snail_reversed
XSN53 N053 N054 snail
XSN54 N054 N055 snail_reversed
XSN55 N055 N056 snail
XSN56 N056 N057 snail_reversed
XSN57 N057 N058 snail
XSN58 N058 N059 snail_reversed
XSN59 N059 N060 snail
XSN60 N060 N061 snail_reversed
XSN61 N061 N062 snail
XSN62 N062 N063 snail_reversed
XSN63 N063 N064 snail
XSN64 N064 N065 snail_reversed
XSN65 N065 N066 snail
XSN66 N066 N067 snail_reversed
XSN67 N067 N068 snail
XSN68 N068 N069 snail_reversed
XSN69 N069 N070 snail
XSN70 N070 N071 snail_reversed
XSN71 N071 N072 snail
XSN72 N072 N073 snail_reversed
XSN73 N073 N074 snail
XSN74 N074 N075 snail_reversed
XSN75 N075 N076 snail
XSN76 N076 N077 snail_reversed
XSN77 N077 N078 snail
XSN78 N078 N079 snail_reversed
XSN79 N079 N080 snail
XSN80 N080 N081 snail_reversed
XSN81 N081 N082 snail
XSN82 N082 N083 snail_reversed
XSN83 N083 N084 snail
XSN84 N084 N085 snail_reversed
XSN85 N085 N086 snail
XSN86 N086 N087 snail_reversed
XSN87 N087 N088 snail
XSN88 N088 N089 snail_reversed
XSN89 N089 N090 snail
XSN90 N090 N091 snail_reversed
XSN91 N091 N092 snail
XSN92 N092 N093 snail_reversed
XSN93 N093 N094 snail
XSN94 N094 N095 snail_reversed
XSN95 N095 N096 snail
XSN96 N096 N097 snail_reversed
XSN97 N097 N098 snail
XSN98 N098 N099 snail_reversed
XSN99 N099 N100 snail
XSN100 N100 N101 snail_reversed
XSN101 N101 N102 snail
XSN102 N102 N103 snail_reversed
XSN103 N103 N104 snail
XSN104 N104 N105 snail_reversed
XSN105 N105 N106 snail
XSN106 N106 N107 snail_reversed
XSN107 N107 N108 snail
XSN108 N108 N109 snail_reversed
XSN109 N109 N110 snail
XSN110 N110 N111 snail_reversed
XSN111 N111 N112 snail
XSN112 N112 N113 snail_reversed
XSN113 N113 N114 snail
XSN114 N114 N115 snail_reversed
XSN115 N115 N116 snail
XSN116 N116 N117 snail_reversed
XSN117 N117 N118 snail
XSN118 N118 N119 snail_reversed
XSN119 N119 N120 snail
XSN120 N120 N121 snail_reversed
XSN121 N121 N122 snail
XSN122 N122 N123 snail_reversed
XSN123 N123 N124 snail
XSN124 N124 N125 snail_reversed
XSN125 N125 N126 snail
XSN126 N126 N127 snail_reversed
XSN127 N127 N128 snail
XSN128 N128 N129 snail_reversed
XSN129 N129 N130 snail
XSN130 N130 N131 snail_reversed
XSN131 N131 N132 snail
XSN132 N132 N133 snail_reversed
XSN133 N133 N134 snail
XSN134 N134 N135 snail_reversed
XSN135 N135 N136 snail
XSN136 N136 N137 snail_reversed
XSN137 N137 N138 snail
XSN138 N138 N139 snail_reversed
XSN139 N139 N140 snail
XSN140 N140 N141 snail_reversed
XSN141 N141 N142 snail
XSN142 N142 N143 snail_reversed
XSN143 N143 N144 snail
XSN144 N144 N145 snail_reversed
XSN145 N145 N146 snail
XSN146 N146 N147 snail_reversed
XSN147 N147 N148 snail
XSN148 N148 N149 snail_reversed
XSN149 N149 N150 snail
XSN150 N150 N151 snail_reversed
XSN151 N151 N152 snail
XSN152 N152 N153 snail_reversed
XSN153 N153 N154 snail
XSN154 N154 N155 snail_reversed
XSN155 N155 N156 snail
XSN156 N156 N157 snail_reversed
XSN157 N157 N158 snail
XSN158 N158 N159 snail_reversed
XSN159 N159 N160 snail
XSN160 N160 N161 snail_reversed
XSN161 N161 N162 snail
XSN162 N162 N163 snail_reversed
XSN163 N163 N164 snail
XSN164 N164 N165 snail_reversed
XSN165 N165 N166 snail
XSN166 N166 N167 snail_reversed
XSN167 N167 N168 snail
XSN168 N168 N169 snail_reversed
XSN169 N169 N170 snail
XSN170 N170 N171 snail_reversed
XSN171 N171 N172 snail
XSN172 N172 N173 snail_reversed
XSN173 N173 N174 snail
XSN174 N174 N175 snail_reversed
XSN175 N175 N176 snail
XSN176 N176 N177 snail_reversed
XSN177 N177 N178 snail
XSN178 N178 N179 snail_reversed
XSN179 N179 N180 snail
XSN180 N180 N181 snail_reversed
XSN181 N181 N182 snail
XSN182 N182 N183 snail_reversed
XSN183 N183 N184 snail
XSN184 N184 N185 snail_reversed
XSN185 N185 N186 snail
XSN186 N186 N187 snail_reversed
XSN187 N187 N188 snail
XSN188 N188 N189 snail_reversed
XSN189 N189 N190 snail
XSN190 N190 N191 snail_reversed
XSN191 N191 N192 snail
XSN192 N192 N193 snail_reversed
XSN193 N193 N194 snail
XSN194 N194 N195 snail_reversed
XSN195 N195 N196 snail
XSN196 N196 N197 snail_reversed
XSN197 N197 N198 snail
XSN198 N198 N199 snail_reversed
XSN199 N199 N200 snail
XSN200 N200 N201 snail_reversed
XSN201 N201 N202 snail
XSN202 N202 N203 snail_reversed
XSN203 N203 N204 snail
XSN204 N204 N205 snail_reversed
XSN205 N205 N206 snail
XSN206 N206 N207 snail_reversed
XSN207 N207 N208 snail
XSN208 N208 N209 snail_reversed
XSN209 N209 N210 snail
XSN210 N210 N211 snail_reversed
XSN211 N211 N212 snail
XSN212 N212 N213 snail_reversed
XSN213 N213 N214 snail
XSN214 N214 N215 snail_reversed
XSN215 N215 N216 snail
XSN216 N216 N217 snail_reversed
XSN217 N217 N218 snail
XSN218 N218 N219 snail_reversed
XSN219 N219 N220 snail
XSN220 N220 N221 snail_reversed
XSN221 N221 N222 snail
XSN222 N222 N223 snail_reversed
XSN223 N223 N224 snail
XSN224 N224 N225 snail_reversed
XSN225 N225 N226 snail
XSN226 N226 N227 snail_reversed
XSN227 N227 N228 snail
XSN228 N228 N229 snail_reversed
XSN229 N229 N230 snail
XSN230 N230 N231 snail_reversed
XSN231 N231 N232 snail
XSN232 N232 N233 snail_reversed
XSN233 N233 N234 snail
XSN234 N234 N235 snail_reversed
XSN235 N235 N236 snail
XSN236 N236 N237 snail_reversed
XSN237 N237 N238 snail
XSN238 N238 N239 snail_reversed
XSN239 N239 N240 snail
XSN240 N240 N241 snail_reversed
XSN241 N241 N242 snail
XSN242 N242 N243 snail_reversed
XSN243 N243 N244 snail
XSN244 N244 N245 snail_reversed
XSN245 N245 N246 snail
XSN246 N246 N247 snail_reversed
XSN247 N247 N248 snail
XSN248 N248 N249 snail_reversed
XSN249 N249 N250 snail
XSN250 N250 N251 snail_reversed
R2 N251 0 R
C1 N001 0 C
C2 N002 0 C
C3 N003 0 C
C4 N004 0 C
C5 N005 0 C
C6 N006 0 C
C7 N007 0 C
C8 N008 0 C
C9 N009 0 C
C10 N010 0 C
C11 N011 0 C
C12 N012 0 C
C13 N013 0 C
C14 N014 0 C
C15 N015 0 C
C16 N016 0 C
C17 N017 0 C
C18 N018 0 C
C19 N019 0 C
C20 N020 0 C
C21 N021 0 C
C22 N022 0 C
C23 N023 0 C
C24 N024 0 C
C25 N025 0 C
C26 N026 0 C
C27 N027 0 C
C28 N028 0 C
C29 N029 0 C
C30 N030 0 C
C31 N031 0 C
C32 N032 0 C
C33 N033 0 C
C34 N034 0 C
C35 N035 0 C
C36 N036 0 C
C37 N037 0 C
C38 N038 0 C
C39 N039 0 C
C40 N040 0 C
C41 N041 0 C
C42 N042 0 C
C43 N043 0 C
C44 N044 0 C
C45 N045 0 C
C46 N046 0 C
C47 N047 0 C
C48 N048 0 C
C49 N049 0 C
C50 N050 0 C
C51 N051 0 C
C52 N052 0 C
C53 N053 0 C
C54 N054 0 C
C55 N055 0 C
C56 N056 0 C
C57 N057 0 C
C58 N058 0 C
C59 N059 0 C
C60 N060 0 C
C61 N061 0 C
C62 N062 0 C
C63 N063 0 C
C64 N064 0 C
C65 N065 0 C
C66 N066 0 C
C67 N067 0 C
C68 N068 0 C
C69 N069 0 C
C70 N070 0 C
C71 N071 0 C
C72 N072 0 C
C73 N073 0 C
C74 N074 0 C
C75 N075 0 C
C76 N076 0 C
C77 N077 0 C
C78 N078 0 C
C79 N079 0 C
C80 N080 0 C
C81 N081 0 C
C82 N082 0 C
C83 N083 0 C
C84 N084 0 C
C85 N085 0 C
C86 N086 0 C
C87 N087 0 C
C88 N088 0 C
C89 N089 0 C
C90 N090 0 C
C91 N091 0 C
C92 N092 0 C
C93 N093 0 C
C94 N094 0 C
C95 N095 0 C
C96 N096 0 C
C97 N097 0 C
C98 N098 0 C
C99 N099 0 C
C100 N100 0 C
C101 N101 0 C
C102 N102 0 C
C103 N103 0 C
C104 N104 0 C
C105 N105 0 C
C106 N106 0 C
C107 N107 0 C
C108 N108 0 C
C109 N109 0 C
C110 N110 0 C
C111 N111 0 C
C112 N112 0 C
C113 N113 0 C
C114 N114 0 C
C115 N115 0 C
C116 N116 0 C
C117 N117 0 C
C118 N118 0 C
C119 N119 0 C
C120 N120 0 C
C121 N121 0 C
C122 N122 0 C
C123 N123 0 C
C124 N124 0 C
C125 N125 0 C
C126 N126 0 C
C127 N127 0 C
C128 N128 0 C
C129 N129 0 C
C130 N130 0 C
C131 N131 0 C
C132 N132 0 C
C133 N133 0 C
C134 N134 0 C
C135 N135 0 C
C136 N136 0 C
C137 N137 0 C
C138 N138 0 C
C139 N139 0 C
C140 N140 0 C
C141 N141 0 C
C142 N142 0 C
C143 N143 0 C
C144 N144 0 C
C145 N145 0 C
C146 N146 0 C
C147 N147 0 C
C148 N148 0 C
C149 N149 0 C
C150 N150 0 C
C151 N151 0 C
C152 N152 0 C
C153 N153 0 C
C154 N154 0 C
C155 N155 0 C
C156 N156 0 C
C157 N157 0 C
C158 N158 0 C
C159 N159 0 C
C160 N160 0 C
C161 N161 0 C
C162 N162 0 C
C163 N163 0 C
C164 N164 0 C
C165 N165 0 C
C166 N166 0 C
C167 N167 0 C
C168 N168 0 C
C169 N169 0 C
C170 N170 0 C
C171 N171 0 C
C172 N172 0 C
C173 N173 0 C
C174 N174 0 C
C175 N175 0 C
C176 N176 0 C
C177 N177 0 C
C178 N178 0 C
C179 N179 0 C
C180 N180 0 C
C181 N181 0 C
C182 N182 0 C
C183 N183 0 C
C184 N184 0 C
C185 N185 0 C
C186 N186 0 C
C187 N187 0 C
C188 N188 0 C
C189 N189 0 C
C190 N190 0 C
C191 N191 0 C
C192 N192 0 C
C193 N193 0 C
C194 N194 0 C
C195 N195 0 C
C196 N196 0 C
C197 N197 0 C
C198 N198 0 C
C199 N199 0 C
C200 N200 0 C
C201 N201 0 C
C202 N202 0 C
C203 N203 0 C
C204 N204 0 C
C205 N205 0 C
C206 N206 0 C
C207 N207 0 C
C208 N208 0 C
C209 N209 0 C
C210 N210 0 C
C211 N211 0 C
C212 N212 0 C
C213 N213 0 C
C214 N214 0 C
C215 N215 0 C
C216 N216 0 C
C217 N217 0 C
C218 N218 0 C
C219 N219 0 C
C220 N220 0 C
C221 N221 0 C
C222 N222 0 C
C223 N223 0 C
C224 N224 0 C
C225 N225 0 C
C226 N226 0 C
C227 N227 0 C
C228 N228 0 C
C229 N229 0 C
C230 N230 0 C
C231 N231 0 C
C232 N232 0 C
C233 N233 0 C
C234 N234 0 C
C235 N235 0 C
C236 N236 0 C
C237 N237 0 C
C238 N238 0 C
C239 N239 0 C
C240 N240 0 C
C241 N241 0 C
C242 N242 0 C
C243 N243 0 C
C244 N244 0 C
C245 N245 0 C
C246 N246 0 C
C247 N247 0 C
C248 N248 0 C
C249 N249 0 C
C250 N250 0 C
.subckt snail P001 P004
J1 P001 P002 rsj(IC1, RN1, CJ1)
J2 P002 P003 rsj(IC1, RN1, CJ1)
J3 P003 P004 rsj(IC1, RN1, CJ1)
J4 P005 P004 rsj(IC2, RN2, CJ2)
P1 P001 P005 phi
.ends
.subckt snail_reversed P001 P005
J5 P002 P003 rsj(IC1, RN1, CJ1)
J6 P003 P004 rsj(IC1, RN1, CJ1)
J7 P004 P005 rsj(IC1, RN1, CJ1)
J8 P001 P005 rsj(IC2, RN2, CJ2)
P2 P001 P002 phi
.ends
.end
